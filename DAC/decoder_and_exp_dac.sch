v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {decoder.sym} -140 -220 0 0 {name=x1}
C {exp_DAC.sym} 160 -170 0 0 {name=x2}
C {iopin.sym} -80 -10 1 0 {name=p27 lab=GND
}
C {iopin.sym} 160 40 1 0 {name=p1 lab=GND
}
C {iopin.sym} 160 -380 3 0 {name=p17 lab=VDD




}
C {iopin.sym} -80 -340 3 0 {name=p2 lab=VDD




}
C {ipin.sym} -160 -200 0 0 {name=p13 sig_type=std_logic lab=A0}
C {ipin.sym} -160 -180 0 0 {name=p3 sig_type=std_logic lab=A1}
C {ipin.sym} -160 -160 0 0 {name=p4 sig_type=std_logic lab=A2}
C {ipin.sym} -160 -140 0 0 {name=p5 sig_type=std_logic lab=A3}
C {opin.sym} 270 -170 0 0 {name=p54 sig_type=std_logic lab=Vout}
