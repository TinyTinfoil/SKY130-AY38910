v {xschem version=3.4.7RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {digital_core_post.sym} -40 -250 0 0 {name=X1 model=digital_core}
C {ipin.sym} -190 -940 0 0 {name=g0 lab=din[7]
}
C {ipin.sym} -190 -1260 0 0 {name=g1 lab=IOB_in[7]
}
C {ipin.sym} -190 -1580 0 0 {name=g2 lab=IOA_in[7]
}
C {ipin.sym} 120 40 2 0 {name=g3 lab=bc1
}
C {ipin.sym} 120 120 2 0 {name=g4 lab=bdir
}
C {ipin.sym} 120 160 2 0 {name=g5 lab=A8
}
C {ipin.sym} 120 200 2 0 {name=g6 lab=nA9
}
C {ipin.sym} 120 230 2 0 {name=g7 lab=rst_n
}
C {ipin.sym} -110 170 0 0 {name=g8 lab=clk
}
C {ipin.sym} 120 80 2 0 {name=g9 lab=bc2
}
C {ipin.sym} -110 130 0 0 {name=g10 lab=clk_en
}
C {ipin.sym} -190 -980 0 0 {name=g11 lab=din[6]
}
C {ipin.sym} -190 -1300 0 0 {name=g12 lab=IOB_in[6]
}
C {ipin.sym} -190 -1620 0 0 {name=g13 lab=IOA_in[6]
}
C {ipin.sym} -190 -1020 0 0 {name=g14 lab=din[5]
}
C {ipin.sym} -190 -1340 0 0 {name=g15 lab=IOB_in[5]
}
C {ipin.sym} -190 -1660 0 0 {name=g16 lab=IOA_in[5]
}
C {ipin.sym} -190 -1060 0 0 {name=g17 lab=din[4]
}
C {ipin.sym} -190 -1380 0 0 {name=g18 lab=IOB_in[4]
}
C {ipin.sym} -190 -1700 0 0 {name=g19 lab=IOA_in[4]
}
C {ipin.sym} -190 -1100 0 0 {name=g20 lab=din[3]
}
C {ipin.sym} -190 -1420 0 0 {name=g21 lab=IOB_in[3]
}
C {ipin.sym} -190 -1740 0 0 {name=g22 lab=IOA_in[3]
}
C {ipin.sym} -190 -1140 0 0 {name=g23 lab=din[2]
}
C {ipin.sym} -190 -1460 0 0 {name=g24 lab=IOB_in[2]
}
C {ipin.sym} -190 -1780 0 0 {name=g25 lab=IOA_in[2]
}
C {ipin.sym} -190 -1180 0 0 {name=g26 lab=din[1]
}
C {ipin.sym} -190 -1500 0 0 {name=g27 lab=IOB_in[1]
}
C {ipin.sym} -190 -1820 0 0 {name=g28 lab=IOA_in[1]
}
C {ipin.sym} -190 -1220 0 0 {name=g29 lab=din[0]
}
C {ipin.sym} -190 -1540 0 0 {name=g30 lab=IOB_in[0]
}
C {ipin.sym} -190 -1860 0 0 {name=g31 lab=IOA_in[0]
}
C {opin.sym} 120 -940 0 0 {name=g32 lab=dout[7]
}
C {opin.sym} 120 -1260 0 0 {name=g33 lab=IOB_out[7]
}
C {opin.sym} 120 -1580 0 0 {name=g34 lab=IOA_out[7]
}
C {opin.sym} -110 50 2 0 {name=g35 lab=IOA_oe
}
C {opin.sym} -110 -40 2 0 {name=g36 lab=IOB_oe
}
C {opin.sym} 120 -730 0 0 {name=g37 lab=C[3]
}
C {opin.sym} 120 -560 0 0 {name=g38 lab=B[3]
}
C {opin.sym} 120 -390 0 0 {name=g39 lab=A[3]
}
C {opin.sym} 120 -980 0 0 {name=g40 lab=dout[6]
}
C {opin.sym} 120 -1300 0 0 {name=g41 lab=IOB_out[6]
}
C {opin.sym} 120 -1620 0 0 {name=g42 lab=IOA_out[6]
}
C {opin.sym} 120 -770 0 0 {name=g43 lab=C[2]
}
C {opin.sym} 120 -600 0 0 {name=g44 lab=B[2]
}
C {opin.sym} 120 -430 0 0 {name=g45 lab=A[2]
}
C {opin.sym} 120 -1020 0 0 {name=g46 lab=dout[5]
}
C {opin.sym} 120 -1340 0 0 {name=g47 lab=IOB_out[5]
}
C {opin.sym} 120 -1660 0 0 {name=g48 lab=IOA_out[5]
}
C {opin.sym} 120 -810 0 0 {name=g49 lab=C[1]
}
C {opin.sym} 120 -640 0 0 {name=g50 lab=B[1]
}
C {opin.sym} 120 -470 0 0 {name=g51 lab=A[1]
}
C {opin.sym} 120 -1060 0 0 {name=g52 lab=dout[4]
}
C {opin.sym} 120 -1380 0 0 {name=g53 lab=IOB_out[4]
}
C {opin.sym} 120 -1700 0 0 {name=g54 lab=IOA_out[4]
}
C {opin.sym} 120 -850 0 0 {name=g55 lab=C[0]
}
C {opin.sym} 120 -680 0 0 {name=g56 lab=B[0]
}
C {opin.sym} 120 -510 0 0 {name=g57 lab=A[0]
}
C {opin.sym} 120 -1100 0 0 {name=g58 lab=dout[3]
}
C {opin.sym} 120 -1420 0 0 {name=g59 lab=IOB_out[3]
}
C {opin.sym} 120 -1740 0 0 {name=g60 lab=IOA_out[3]
}
C {opin.sym} 120 -1140 0 0 {name=g61 lab=dout[2]
}
C {opin.sym} 120 -1460 0 0 {name=g62 lab=IOB_out[2]
}
C {opin.sym} 120 -1780 0 0 {name=g63 lab=IOA_out[2]
}
C {opin.sym} 120 -1180 0 0 {name=g64 lab=dout[1]
}
C {opin.sym} 120 -1500 0 0 {name=g65 lab=IOB_out[1]
}
C {opin.sym} 120 -1820 0 0 {name=g66 lab=IOA_out[1]
}
C {opin.sym} 120 -1220 0 0 {name=g67 lab=dout[0]
}
C {opin.sym} 120 -1540 0 0 {name=g68 lab=IOB_out[0]
}
C {opin.sym} 120 -1860 0 0 {name=g69 lab=IOA_out[0]
}
C {iopin.sym} -110 -230 2 0 {name=g70 lab=VPWR
}
C {iopin.sym} -110 -190 2 0 {name=g71 lab=VGND
}
