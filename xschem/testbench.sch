v {xschem version=3.4.7RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {jt49_bus.sym} -30 -30 0 0 {name=a1 model=jt49_bus

***Icarus_verilog***
device_model=".model counter d_cosim simulation=\\"ivlng\\" sim_args=[\\"counter\\"] delay=0"

tclcommand="edit_file [abs_sym_path counter.v]"}
